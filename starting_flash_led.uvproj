# Keil uVision project starting_flash_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: starting_flash_led
  c flags: Optimize=8 SizeSpeed=1
